# Keil uVision project stm32h743.uvprojx, settings and files
target Target (6160000::V6.16::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: openblt_stm32h743
  AfterMake: fromelf --m32 --output=..\bin\openblt_stm32h743.srec ..\bin\openblt_stm32h743.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32H743xx
  c include: ..\..\Boot;..\lib;..\lib\CMSIS\Device\ST\STM32H7xx\Include;..\lib\CMSIS\Include;..\lib\STM32H7xx_HAL_Driver\Inc;..\lib\STM32H7xx_HAL_Driver\Inc\Legacy;..\lib\TinyUSB;..\lib\uip;..\..\..\..\Source;..\..\..\..\Source\ARMCM7_STM32H7;..\..\..\..\Source\third_party\uip\uip;..\..\..\..\Source\third_party\uip\apps\dhcpc;..\..\..\..\Source\third_party\tinyusb\src
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\stm32h743.sct
  group Lib
    ../lib/: stm32h7xx_hal_conf.h system_stm32h7xx.c
    ../lib/CMSIS/Device/ST/STM32H7xx/Include/: stm32h7xx.h stm32h743xx.h system_stm32h7xx.h
    ../lib/CMSIS/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm3.h core_cm4.h core_cm7.h core_cm23.h core_cm33.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
    ../lib/STM32H7xx_HAL_Driver/Inc/: stm32h7xx_hal.h stm32h7xx_hal_cortex.h stm32h7xx_hal_def.h stm32h7xx_hal_dma.h stm32h7xx_hal_dma_ex.h stm32h7xx_hal_exti.h stm32h7xx_hal_fdcan.h stm32h7xx_hal_flash.h stm32h7xx_hal_flash_ex.h stm32h7xx_hal_gpio.h stm32h7xx_hal_gpio_ex.h stm32h7xx_hal_hsem.h stm32h7xx_hal_i2c.h stm32h7xx_hal_i2c_ex.h stm32h7xx_hal_mdma.h stm32h7xx_hal_pcd.h stm32h7xx_hal_pcd_ex.h stm32h7xx_hal_pwr.h stm32h7xx_hal_pwr_ex.h stm32h7xx_hal_rcc.h stm32h7xx_hal_rcc_ex.h stm32h7xx_hal_tim.h stm32h7xx_hal_tim_ex.h stm32h7xx_ll_bus.h stm32h7xx_ll_cortex.h stm32h7xx_ll_crs.h stm32h7xx_ll_dma.h stm32h7xx_ll_dmamux.h stm32h7xx_ll_exti.h stm32h7xx_ll_gpio.h stm32h7xx_ll_pwr.h stm32h7xx_ll_rcc.h stm32h7xx_ll_system.h stm32h7xx_ll_usart.h stm32h7xx_ll_usb.h stm32h7xx_ll_utils.h stm32h7xx_hal_eth.h stm32h7xx_hal_eth_ex.h
    ../lib/STM32H7xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_dma.c stm32h7xx_ll_exti.c stm32h7xx_ll_gpio.c stm32h7xx_ll_rcc.c stm32h7xx_ll_usart.c stm32h7xx_ll_usb.c stm32h7xx_ll_utils.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c
    ../lib/uip/: clock-arch.c clock-arch.h lan8742.c lan8742.h netdev.c netdev.h uip-conf.h
    ../lib/TinyUSB/: tusb_config.h usb_descriptors.c
  group App
    ../: blt_conf.h hooks.c led.c led.h main.c startup_stm32h743xx.s shared_params.c shared_params.h
  group Core
    ../../../../Source/: backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h file.c file.h net.c net.h nvm.h plausibility.h rs232.h timer.h usb.h xcp.c xcp.h asserts.c asserts.h mb.c mb.h events.c events.h infotable.c infotable.h
    ../../../../Source/ARMCM7_STM32H7/: can.c cpu.c flash.c flash.h nvm.c rs232.c timer.c types.h usb.c mbrtu.c
    ../../../../Source/ARMCM7_STM32H7/Keil/: cpu_comp.c
    ../../../../Source/third_party/uip/apps/dhcpc/: dhcpc.c dhcpc.h
    ../../../../Source/third_party/uip/uip/: clock.h lc.h lc-addrlabels.h lc-switch.h pt.h uip.c uip.h uip_arch.h uip_arp.c uip_arp.h uip_timer.c uip_timer.h uip-fw.c uip-fw.h uiplib.c uiplib.h uipopt.h
  group Core/third_party/tinyusb
    ../../../../Source/third_party/tinyusb/src/: tusb.c tusb.h tusb_option.h
    ../../../../Source/third_party/tinyusb/src/class/vendor/: vendor_device.c vendor_device.h
    ../../../../Source/third_party/tinyusb/src/common/: tusb_common.h tusb_compiler.h tusb_debug.h tusb_fifo.c tusb_fifo.h tusb_mcu.h tusb_private.h tusb_types.h tusb_verify.h
    ../../../../Source/third_party/tinyusb/src/device/: dcd.h usbd.c usbd.h usbd_control.c usbd_pvt.h
    ../../../../Source/third_party/tinyusb/src/osal/: osal.h osal_none.h
    ../../../../Source/third_party/tinyusb/src/portable/: usb_board.c
    ../../../../Source/third_party/tinyusb/src/portable/synopsys/dwc2/: dcd_dwc2.c dwc2_common.c dwc2_common.h dwc2_stm32.h dwc2_type.h
