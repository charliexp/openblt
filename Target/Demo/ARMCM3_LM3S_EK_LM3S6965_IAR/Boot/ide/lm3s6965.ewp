# IAR project lm3s6965.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S6965 TexasInstruments LM3S6965
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; DEBUG; PRINTF_INCLUDE_CONFIG_H
  ICCARM.CCIncludePath2: ..\..\..\..\Source; ..\..\..\..\Source\third_party\fatfs\source; ..\..\..\..\Source\third_party\uip\uip; ..\..\..\..\Source\third_party\uip\apps\dhcpc; ..\..\..\..\Source\ARMCM3_LM3S; ..\..\..\..\Source\ARMCM3_LM3S\IAR; ..; ..\lib; ..\lib\inc; ..\lib\driverlib; ..\lib\fatfs; ..\lib\uip; ..\lib\printf
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openblt_ek_lm3s6965.srec
  ILINK.IlinkOutputFile: openblt_ek_lm3s6965.out
  ILINK.IlinkIcfFile: ..\LM3S6965.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group Boot
    ../: blt_conf.h cstart.s hooks.c led.c led.h main.c shared_params.c shared_params.h vectors.c
  group Boot/lib/driverlib
    ../lib/driverlib/: cpulib.c cpulib.h debug.h ethernet.c ethernet.h flashlib.c flashlib.h gpio.c gpio.h interrupt.c interrupt.h pin_map.h ssi.c ssi.h sysctl.c sysctl.h uartlib.c uartlib.h
  group Boot/lib/fatfs
    ../lib/fatfs/: ffconf.h mmc.c
  group Boot/lib/inc
    ../lib/inc/: hw_ethernet.h hw_flash.h hw_gpio.h hw_ints.h hw_memmap.h hw_nvic.h hw_ssi.h hw_sysctl.h hw_types.h hw_uart.h
  group Boot/lib/printf
    ../lib/printf/: printf.c printf.h printf_config.h
  group Boot/lib/uip
    ../lib/uip/: clock-arch.c clock-arch.h netdev.c netdev.h uip-conf.h
  group Source
    ../../../../Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h com.c com.h cop.c cop.h cpu.h events.c events.h file.c file.h infotable.c infotable.h mb.c mb.h net.c net.h nvm.h plausibility.h rs232.h timer.h xcp.c xcp.h
  group Source/ARMCM3_LM3S
    ../../../../Source/ARMCM3_LM3S/: cpu.c flash.c flash.h mbrtu.c nvm.c rs232.c timer.c timer.h
  group Source/ARMCM3_LM3S/IAR
    ../../../../Source/ARMCM3_LM3S/IAR/: cpu_comp.c
  group Source/third_party/fatfs
    ../../../../Source/third_party/fatfs/source/: diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group Source/third_party/uip
    ../../../../Source/third_party/uip/uip/: clock.h lc-addrlabels.h lc-switch.h lc.h pt.h uip-fw.h uip-neighbor.h uip-split.h uip.c uip.h uip_arch.h uip_arp.c uip_arp.h uip_timer.c uip_timer.h uiplib.c uiplib.h uipopt.h
    ../../../../Source/third_party/uip/apps/dhcpc/: dhcpc.c dhcpc.h
