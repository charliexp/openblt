# IAR project s32k144.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K144 NXP S32K144
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_S32K144HFT0VLLT
  ICCARM.CCIncludePath2: ..; ..\lib; ..\..\..\..\Source; ..\..\..\..\Source\ARMCM4_S32K14; ..\..\..\..\Source\ARMCM4_S32K14\IAR
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: START_FROM_FLASH
  OBJCOPY.OOCOutputFile: openblt_s32k144.srec
  ILINK.IlinkOutputFile: openblt_s32k144.out
  ILINK.IlinkIcfFile: ..\S32K144_64_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group Boot
    ../: blt_conf.h hooks.c led.c led.h main.c startup_S32K144.s
  group Boot/lib
    ../lib/: devassert.h device_registers.h s32_core_cm4.h S32K144.h S32K144_features.h startup.c startup.h system_S32K144.c system_S32K144.h
  group Source
    ../../../../Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h events.c events.h file.c file.h mb.c mb.h net.c net.h nvm.h plausibility.h rs232.h timer.h usb.h xcp.c xcp.h
  group Source/ARMCM4_S32K14
    ../../../../Source/ARMCM4_S32K14/: can.c cpu.c flash.c flash.h mbrtu.c nvm.c rs232.c timer.c types.h
  group Source/ARMCM4_S32K14/IAR
    ../../../../Source/ARMCM4_S32K14/IAR/: cpu_comp.c
