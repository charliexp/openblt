# Keil uVision project stm32c092.uvprojx, settings and files
target Target (6160000::V6.16::ARMCLANG)
  device: STM32C092RCTx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x200077FF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: openblt_stm32c092
  AfterMake: fromelf --m32 --output=..\bin\openblt_stm32c092.srec ..\bin\openblt_stm32c092.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32C092xx
  c include: ..\..\Boot;..\lib;..\lib\CMSIS\Device\ST\STM32C0xx\Include;..\lib\CMSIS\Include;..\lib\STM32C0xx_HAL_Driver\Inc;..\lib\STM32C0xx_HAL_Driver\Inc\Legacy;..\..\..\..\Source;..\..\..\..\Source\ARMCM0_STM32C0;..\..\..\..\Source\ARMCM0_STM32C0\Keil
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x7800
  scatter file: ..\stm32c092.sct
  group Lib
    ../lib/: stm32c0xx_hal_conf.h system_stm32c0xx.c
    ../lib/CMSIS/Device/ST/STM32C0xx/Include/: stm32c0xx.h stm32c092xx.h system_stm32c0xx.h
    ../lib/CMSIS/Include/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm0plus.h
    ../lib/STM32C0xx_HAL_Driver/Inc/: stm32c0xx_hal.h stm32c0xx_hal_cortex.h stm32c0xx_hal_def.h stm32c0xx_hal_dma.h stm32c0xx_hal_dma_ex.h stm32c0xx_hal_exti.h stm32c0xx_hal_fdcan.h stm32c0xx_hal_flash.h stm32c0xx_hal_flash_ex.h stm32c0xx_hal_gpio.h stm32c0xx_hal_gpio_ex.h stm32c0xx_hal_pwr.h stm32c0xx_hal_pwr_ex.h stm32c0xx_hal_rcc.h stm32c0xx_hal_rcc_ex.h stm32c0xx_ll_bus.h stm32c0xx_ll_cortex.h stm32c0xx_ll_dma.h stm32c0xx_ll_dmamux.h stm32c0xx_ll_exti.h stm32c0xx_ll_gpio.h stm32c0xx_ll_pwr.h stm32c0xx_ll_rcc.h stm32c0xx_ll_system.h stm32c0xx_ll_usart.h stm32c0xx_ll_utils.h
    ../lib/STM32C0xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal.c stm32c0xx_hal_cortex.c stm32c0xx_hal_dma.c stm32c0xx_hal_dma_ex.c stm32c0xx_hal_exti.c stm32c0xx_hal_fdcan.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_ll_dma.c stm32c0xx_ll_exti.c stm32c0xx_ll_gpio.c stm32c0xx_ll_rcc.c stm32c0xx_ll_usart.c stm32c0xx_ll_utils.c
  group App
    ../: blt_conf.h flash_layout.c hooks.c led.c led.h main.c startup_stm32c092xx.s
  group Core
    ../../../../Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h file.c file.h infotable.c infotable.h mb.c mb.h net.c net.h nvm.h plausibility.h rs232.h timer.h usb.h xcp.c xcp.h events.c events.h
    ../../../../Source/ARMCM0_STM32C0/: can.c cpu.c flash.c flash.h mbrtu.c nvm.c rs232.c timer.c types.h
    ../../../../Source/ARMCM0_STM32C0/Keil/: cpu_comp.c
software components: CMSIS:CORE 5.6.0
