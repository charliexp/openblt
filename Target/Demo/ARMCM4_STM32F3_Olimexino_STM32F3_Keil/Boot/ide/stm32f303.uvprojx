# Keil uVision project stm32f303.uvprojx, settings and files
target Target (6160000::V6.16::ARMCLANG)
  device: STM32F303RCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: openblt_olimexino_stm32f3
  AfterMake: fromelf --m32 --output=..\bin\openblt_olimexino_stm32f3.srec ..\bin\openblt_olimexino_stm32f3.axf
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F303xC,PRINTF_INCLUDE_CONFIG_H
  c include: ..\..\Boot;..\lib;..\lib\CMSIS\Device\ST\STM32F3xx\Include;..\lib\CMSIS\Include;..\lib\FatFS;..\lib\TinyUSB;..\lib\printf;..\lib\STM32F3xx_HAL_Driver\Inc;..\..\..\..\Source;..\..\..\..\Source\ARMCM4_STM32F3;..\..\..\..\Source\ARMCM4_STM32F3\Keil;..\..\..\..\Source\third_party\fatfs\source;..\..\..\..\Source\third_party\tinyusb\src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  scatter file: ..\olimexino_stm32f3.sct
  group Lib
    ../lib/: stm32f3xx_hal_conf.h system_stm32f3xx.c
    ../lib/CMSIS/Device/ST/STM32F3xx/Include/: stm32f3xx.h stm32f303xc.h system_stm32f3xx.h
    ../lib/CMSIS/Include/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm4.h tz_context.h
    ../lib/FatFS/: ffconf.h mmc.c
    ../lib/STM32F3xx_HAL_Driver/Inc/: stm32f3xx_hal.h stm32f3xx_hal_can.h stm32f3xx_hal_cortex.h stm32f3xx_hal_def.h stm32f3xx_hal_dma.h stm32f3xx_hal_dma_ex.h stm32f3xx_hal_exti.h stm32f3xx_hal_flash.h stm32f3xx_hal_flash_ex.h stm32f3xx_hal_gpio.h stm32f3xx_hal_gpio_ex.h stm32f3xx_hal_i2c.h stm32f3xx_hal_i2c_ex.h stm32f3xx_hal_pcd.h stm32f3xx_hal_pcd_ex.h stm32f3xx_hal_pwr.h stm32f3xx_hal_pwr_ex.h stm32f3xx_hal_rcc.h stm32f3xx_hal_rcc_ex.h stm32f3xx_ll_bus.h stm32f3xx_ll_cortex.h stm32f3xx_ll_dma.h stm32f3xx_ll_exti.h stm32f3xx_ll_gpio.h stm32f3xx_ll_pwr.h stm32f3xx_ll_rcc.h stm32f3xx_ll_spi.h stm32f3xx_ll_system.h stm32f3xx_ll_usart.h stm32f3xx_ll_usb.h stm32f3xx_ll_utils.h
    ../lib/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_can.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_exti.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_ll_dma.c stm32f3xx_ll_exti.c stm32f3xx_ll_gpio.c stm32f3xx_ll_rcc.c stm32f3xx_ll_spi.c stm32f3xx_ll_usart.c stm32f3xx_ll_usb.c stm32f3xx_ll_utils.c
    ../lib/TinyUSB/: tusb_config.h usb_descriptors.c
    ../lib/printf/: printf.c printf.h printf_config.h
  group App
    ../: blt_conf.h flash_layout.c hooks.c led.c led.h main.c startup_stm32f303xc.s
  group Core
    ../../../../Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h file.c file.h net.c net.h nvm.h plausibility.h rs232.h timer.h usb.h xcp.c xcp.h mb.c mb.h infotable.c infotable.h events.c events.h
    ../../../../Source/ARMCM4_STM32F3/: can.c cpu.c flash.c flash.h nvm.c rs232.c timer.c types.h usb.c mbrtu.c
    ../../../../Source/ARMCM4_STM32F3/Keil/: cpu_comp.c
    ../../../../Source/third_party/fatfs/source/: diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group Core/third_party/tinyusb
    ../../../../Source/third_party/tinyusb/src/: tusb.c tusb.h tusb_option.h
    ../../../../Source/third_party/tinyusb/src/class/vendor/: vendor_device.c vendor_device.h
    ../../../../Source/third_party/tinyusb/src/common/: tusb_common.h tusb_compiler.h tusb_debug.h tusb_fifo.c tusb_fifo.h tusb_mcu.h tusb_private.h tusb_types.h tusb_verify.h
    ../../../../Source/third_party/tinyusb/src/device/: dcd.h usbd.c usbd.h usbd_control.c usbd_pvt.h
    ../../../../Source/third_party/tinyusb/src/osal/: osal.h osal_none.h
    ../../../../Source/third_party/tinyusb/src/portable/: usb_board.c
    ../../../../Source/third_party/tinyusb/src/portable/st/stm32_fsdev/: dcd_stm32_fsdev.c fsdev_stm32.h fsdev_type.h
