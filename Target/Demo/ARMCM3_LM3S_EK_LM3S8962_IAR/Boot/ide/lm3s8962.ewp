# IAR project lm3s8962.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S8962 TexasInstruments LM3S8962
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\Source; ..\..\..\..\Source\ARMCM3_LM3S; ..\..\..\..\Source\ARMCM3_LM3S\IAR; ..; ..\lib; ..\lib\inc; ..\lib\driverlib
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openblt_ek_lm3s8962.srec
  ILINK.IlinkOutputFile: openblt_ek_lm3s8962.out
  ILINK.IlinkIcfFile: ..\LM3S8962.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group Boot
    ../: blt_conf.h cstart.s flash_layout.c hooks.c led.c led.h main.c vectors.c
  group Boot/lib/driverlib
    ../lib/driverlib/: canlib.c canlib.h cpulib.c cpulib.h debug.h flashlib.c flashlib.h gpio.c gpio.h interrupt.c interrupt.h sysctl.c sysctl.h uartlib.c uartlib.h
  group Boot/lib/inc
    ../lib/inc/: hw_can.h hw_flash.h hw_gpio.h hw_ints.h hw_memmap.h hw_nvic.h hw_sysctl.h hw_types.h hw_uart.h
  group Source
    ../../../../Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h events.c events.h infotable.c infotable.h mb.c mb.h nvm.h plausibility.h rs232.h timer.h xcp.c xcp.h
  group Source/ARMCM3_LM3S
    ../../../../Source/ARMCM3_LM3S/: can.c cpu.c flash.c flash.h mbrtu.c nvm.c rs232.c timer.c types.h
  group Source/ARMCM3_LM3S/IAR
    ../../../../Source/ARMCM3_LM3S/IAR/: cpu_comp.c
