# IAR project stm32h563.ewp, settings and files
configuration stm32h563 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H563ZI ST STM32H563ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32H563xx
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..; ..\lib; ..\lib\CMSIS\Include; ..\lib\CMSIS\Device\ST\STM32H5xx\Include; ..\lib\STM32H5xx_HAL_Driver\Inc; ..\lib\STM32H5xx_HAL_Driver\Inc\Legacy; ..\lib\TinyUSB; ..\lib\uip; ..\..\..\..\Source; ..\..\..\..\Source\ARMCM33_STM32H5; ..\..\..\..\Source\third_party\uip\uip; ..\..\..\..\Source\third_party\uip\apps\dhcpc; ..\..\..\..\Source\third_party\tinyusb\src
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openblt_stm32h563.srec
  ILINK.IlinkOutputFile: openblt_stm32h563.out
  ILINK.IlinkIcfFile: ..\stm32h563xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Boot
    ../: blt_conf.h hooks.c led.c led.h main.c shared_params.c shared_params.h startup_stm32h563xx.s
  group Boot/lib
    ../lib/: stm32h5xx_hal_conf.h system_stm32h5xx.c
  group Boot/lib/CMSIS
    ../lib/CMSIS/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_cm85.h core_sc000.h core_sc300.h core_starmc1.h mpu_armv7.h mpu_armv8.h pac_armv81.h pmu_armv8.h tz_context.h
    ../lib/CMSIS/Device/ST/STM32H5xx/Include/: stm32h563xx.h stm32h5xx.h system_stm32h5xx.h
  group Boot/lib/HAL
    ../lib/STM32H5xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_eth.c stm32h5xx_hal_eth_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_fdcan.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pcd.c stm32h5xx_hal_pcd_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_ll_dma.c stm32h5xx_ll_exti.c stm32h5xx_ll_gpio.c stm32h5xx_ll_icache.c stm32h5xx_ll_pwr.c stm32h5xx_ll_rcc.c stm32h5xx_ll_usart.c stm32h5xx_ll_usb.c stm32h5xx_ll_utils.c
    ../lib/STM32H5xx_HAL_Driver/Inc/: stm32h5xx_hal.h stm32h5xx_hal_cortex.h stm32h5xx_hal_def.h stm32h5xx_hal_dma.h stm32h5xx_hal_dma_ex.h stm32h5xx_hal_eth.h stm32h5xx_hal_eth_ex.h stm32h5xx_hal_exti.h stm32h5xx_hal_fdcan.h stm32h5xx_hal_flash.h stm32h5xx_hal_flash_ex.h stm32h5xx_hal_gpio.h stm32h5xx_hal_gpio_ex.h stm32h5xx_hal_pcd.h stm32h5xx_hal_pcd_ex.h stm32h5xx_hal_pwr.h stm32h5xx_hal_pwr_ex.h stm32h5xx_hal_rcc.h stm32h5xx_hal_rcc_ex.h stm32h5xx_ll_bus.h stm32h5xx_ll_cortex.h stm32h5xx_ll_crs.h stm32h5xx_ll_dma.h stm32h5xx_ll_exti.h stm32h5xx_ll_gpio.h stm32h5xx_ll_icache.h stm32h5xx_ll_pwr.h stm32h5xx_ll_rcc.h stm32h5xx_ll_system.h stm32h5xx_ll_usart.h stm32h5xx_ll_usb.h stm32h5xx_ll_utils.h
  group Boot/lib/TinyUSB
    ../lib/TinyUSB/: tusb_config.h usb_descriptors.c
  group Boot/lib/uip
    ../lib/uip/: clock-arch.c clock-arch.h lan8742.c lan8742.h netdev.c netdev.h uip-conf.h
  group Source
    ../../../../Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h events.c events.h file.c file.h infotable.c infotable.h mb.c mb.h net.c net.h nvm.h plausibility.h rs232.h timer.h usb.h xcp.c xcp.h
  group Source/ARMCM33_STM32H5
    ../../../../Source/ARMCM33_STM32H5/: can.c cpu.c flash.c flash.h mbrtu.c nvm.c rs232.c timer.c types.h usb.c
  group Source/ARMCM33_STM32H5/IAR
    ../../../../Source/ARMCM33_STM32H5/IAR/: cpu_comp.c
  group Source/third_party/tinyusb
    ../../../../Source/third_party/tinyusb/src/device/: dcd.h usbd.c usbd.h usbd_control.c usbd_pvt.h
    ../../../../Source/third_party/tinyusb/src/portable/st/stm32_fsdev/: dcd_stm32_fsdev.c fsdev_stm32.h fsdev_type.h
    ../../../../Source/third_party/tinyusb/src/osal/: osal.h osal_none.h
    ../../../../Source/third_party/tinyusb/src/: tusb.c tusb.h tusb_option.h
    ../../../../Source/third_party/tinyusb/src/common/: tusb_common.h tusb_compiler.h tusb_debug.h tusb_fifo.c tusb_fifo.h tusb_mcu.h tusb_private.h tusb_types.h tusb_verify.h
    ../../../../Source/third_party/tinyusb/src/portable/: usb_board.c
    ../../../../Source/third_party/tinyusb/src/class/vendor/: vendor_device.c vendor_device.h
  group Source/third_party/uip
    ../../../../Source/third_party/uip/uip/: clock.h lc-addrlabels.h lc-switch.h lc.h pt.h uip-fw.c uip-fw.h uip.c uip.h uip_arch.h uip_arp.c uip_arp.h uip_timer.c uip_timer.h uiplib.c uiplib.h uipopt.h
    ../../../../Source/third_party/uip/apps/dhcpc/: dhcpc.c dhcpc.h
