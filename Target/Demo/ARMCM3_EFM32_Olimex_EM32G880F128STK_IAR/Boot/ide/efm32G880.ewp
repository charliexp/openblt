# IAR project efm32G880.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32G880F128 EnergyMicro EFM32G880F128
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: EFM32G880F128
  ICCARM.CCIncludePath2: ..\..\..\..\Source; ..\..\..\..\Source\ARMCM3_EFM32; ..\..\..\..\Source\ARMCM3_EFM32\IAR; ..; ..\lib; ..\lib\CMSIS\CM3\CoreSupport; ..\lib\CMSIS\CM3\DeviceSupport\EnergyMicro\EFM32; ..\lib\efm32lib\inc; ..\lib\efm32lib\src
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openblt_olimex_efm32g880.srec
  ILINK.IlinkOutputFile: openblt_olimex_efm32g880.out
  ILINK.IlinkIcfFile: ..\memory.x
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group (top)
    ../: cstart.s vectors.c
  group Boot
    ../: blt_conf.h hooks.c main.c
  group Boot/lib/cmsis/coresupport
    ../lib/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h core_cmFunc.h core_cmInstr.h
  group Boot/lib/cmsis/devicesupport
    ../lib/CMSIS/CM3/DeviceSupport/EnergyMicro/EFM32/: efm32.h efm32g880f128.h system_efm32.c system_efm32.h
  group Boot/lib/efm32lib
    ../lib/efm32lib/src/: efm32_acmp.c efm32_adc.c efm32_aes.c efm32_assert.c efm32_cmu.c efm32_dac.c efm32_dbg.c efm32_dma.c efm32_ebi.c efm32_emu.c efm32_gpio.c efm32_i2c.c efm32_int.c efm32_lcd.c efm32_lesense.c efm32_letimer.c efm32_leuart.c efm32_mpu.c efm32_msc.c efm32_opamp.c efm32_pcnt.c efm32_prs.c efm32_rmu.c efm32_rtc.c efm32_system.c efm32_timer.c efm32_usart.c efm32_vcmp.c efm32_wdog.c
    ../lib/efm32lib/inc/: efm32_acmp.h efm32_adc.h efm32_aes.h efm32_assert.h efm32_bitband.h efm32_chip.h efm32_cmu.h efm32_common.h efm32_dac.h efm32_dbg.h efm32_dma.h efm32_ebi.h efm32_emu.h efm32_gpio.h efm32_i2c.h efm32_int.h efm32_lcd.h efm32_lesense.h efm32_letimer.h efm32_leuart.h efm32_mpu.h efm32_msc.h efm32_opamp.h efm32_pcnt.h efm32_prs.h efm32_rmu.h efm32_rtc.h efm32_system.h efm32_timer.h efm32_usart.h efm32_vcmp.h efm32_wdog.h
  group Source
    ../../../../Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h com.c com.h cop.c cop.h cpu.h events.c events.h infotable.c infotable.h mb.c mb.h nvm.h plausibility.h rs232.h timer.h xcp.c xcp.h
  group Source/ARMCM3_EFM32
    ../../../../Source/ARMCM3_EFM32/: cpu.c flash.c flash.h mbrtu.c nvm.c rs232.c timer.c types.h
  group Source/ARMCM3_EFM32/IAR
    ../../../../Source/ARMCM3_EFM32/IAR/: cpu_comp.c
