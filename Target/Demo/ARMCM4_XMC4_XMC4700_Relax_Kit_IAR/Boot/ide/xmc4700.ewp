# IAR project xmc4700.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: XMC4700-F144x2048 Infineon XMC4700-F144x2048
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: XMC4700_F144x2048; XMC_ETH_PHY_KSZ8081RNB
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\; ..\lib; ..\lib\cmsis; ..\lib\uip; ..\lib\xmclib\inc; ..\lib\FatFS; ..\lib\FatFS\SDMMC_BLOCK; ..\lib\TinyUSB; ..\..\..\..\Source; ..\..\..\..\Source\ARMCM4_XMC4; ..\..\..\..\Source\ARMCM4_XMC4\IAR; ..\..\..\..\Source\third_party\uip\uip; ..\..\..\..\Source\third_party\uip\apps\dhcpc; ..\..\..\..\Source\third_party\fatfs\source; ..\..\..\..\Source\third_party\tinyusb\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openblt_xmc4700.srec
  ILINK.IlinkOutputFile: openblt_xmc4700.out
  ILINK.IlinkIcfFile: ..\cfg\memory.x
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  group Boot
    ../: blt_conf.h hooks.c led.c led.h main.c shared_params.c shared_params.h startup_XMC4700.s
  group Boot/lib
    ../lib/: system_XMC4700.c system_XMC4700.h XMC4700.h
  group Boot/lib/cmsis
    ../lib/cmsis/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h
  group Boot/lib/fatfs
    ../lib/FatFS/: ffconf.h mmc.c
    ../lib/FatFS/SDMMC_BLOCK/: sdmmc_block.c sdmmc_block.h sdmmc_block_conf.c sdmmc_block_conf.h sdmmc_block_extern.h sdmmc_block_private_sd.c sdmmc_block_private_sd.h
  group Boot/lib/tinyusb
    ../lib/TinyUSB/: tusb_config.h usb_descriptors.c
  group Boot/lib/uip
    ../lib/uip/: clock-arch.c clock-arch.h netdev.c netdev.h uip-conf.h
  group Boot/lib/xmclib
    ../lib/xmclib/inc/: xmc4_ccu4_map.h xmc4_ccu8_map.h xmc4_eru_map.h xmc4_flash.h xmc4_gpio.h xmc4_gpio_map.h xmc4_rtc.h xmc4_scu.h xmc4_usic_map.h xmc_can.h xmc_can_map.h xmc_ccu4.h xmc_ccu8.h xmc_common.h xmc_dac.h xmc_device.h xmc_dma.h xmc_dma_map.h xmc_dsd.h xmc_ebu.h xmc_ecat.h xmc_ecat_map.h xmc_eru.h xmc_eth_mac.h xmc_eth_mac_map.h xmc_eth_phy.h xmc_fce.h xmc_flash.h xmc_gpio.h xmc_hrpwm.h xmc_hrpwm_map.h xmc_i2c.h xmc_i2s.h xmc_ledts.h xmc_posif.h xmc_posif_map.h xmc_rtc.h xmc_scu.h xmc_sdmmc.h xmc_spi.h xmc_uart.h xmc_usbd.h xmc_usbd_regs.h xmc_usbh.h xmc_usic.h xmc_vadc.h xmc_vadc_map.h xmc_wdt.h
    ../lib/xmclib/src/: xmc4_eru.c xmc4_flash.c xmc4_gpio.c xmc4_rtc.c xmc4_scu.c xmc_can.c xmc_ccu4.c xmc_ccu8.c xmc_common.c xmc_dac.c xmc_dma.c xmc_dsd.c xmc_ebu.c xmc_ecat.c xmc_eru.c xmc_eth_mac.c xmc_eth_phy_dp83848.c xmc_eth_phy_ksz8031rnl.c xmc_eth_phy_ksz8081rnb.c xmc_fce.c xmc_gpio.c xmc_hrpwm.c xmc_i2c.c xmc_i2s.c xmc_ledts.c xmc_posif.c xmc_rtc.c xmc_sdmmc.c xmc_spi.c xmc_uart.c xmc_usbd.c xmc_usbh.c xmc_usic.c xmc_vadc.c xmc_wdt.c
  group Source
    ../../../../Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h events.c events.h file.c file.h mb.c mb.h net.c net.h nvm.h plausibility.h rs232.h timer.h usb.h xcp.c xcp.h
  group Source/ARMCM4_XMC4
    ../../../../Source/ARMCM4_XMC4/: can.c cpu.c flash.c flash.h mbrtu.c nvm.c rs232.c timer.c types.h usb.c
  group Source/ARMCM4_XMC4/IAR
    ../../../../Source/ARMCM4_XMC4/IAR/: cpu_comp.c
  group Source/third_party/fatfs
    ../../../../Source/third_party/fatfs/source/: diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group Source/third_party/tinyusb
    ../../../../Source/third_party/tinyusb/src/device/: dcd.h usbd.c usbd.h usbd_control.c usbd_pvt.h
    ../../../../Source/third_party/tinyusb/src/portable/synopsys/dwc2/: dcd_dwc2.c dwc2_common.c dwc2_common.h dwc2_type.h dwc2_xmc.h
    ../../../../Source/third_party/tinyusb/src/osal/: osal.h osal_none.h
    ../../../../Source/third_party/tinyusb/src/: tusb.c tusb.h tusb_option.h
    ../../../../Source/third_party/tinyusb/src/common/: tusb_common.h tusb_compiler.h tusb_debug.h tusb_fifo.c tusb_fifo.h tusb_mcu.h tusb_private.h tusb_types.h tusb_verify.h
    ../../../../Source/third_party/tinyusb/src/portable/: usb_board.c
    ../../../../Source/third_party/tinyusb/src/class/vendor/: vendor_device.c vendor_device.h
  group Source/third_party/uip
    ../../../../Source/third_party/uip/uip/: clock.h lc-addrlabels.h lc-switch.h lc.h pt.h uip.c uip.h uip_arch.h uip_arp.c uip_arp.h uip_timer.c uip_timer.h uiplib.c uiplib.h uipopt.h
    ../../../../Source/third_party/uip/apps/dhcpc/: dhcpc.c dhcpc.h
