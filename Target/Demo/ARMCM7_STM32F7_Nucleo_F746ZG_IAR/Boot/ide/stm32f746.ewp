# IAR project stm32f746.ewp, settings and files
configuration stm32f746 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746ZG ST STM32F746ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32F746xx
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..; ..\lib; ..\lib\CMSIS\Include; ..\lib\CMSIS\Device\ST\STM32F7xx\Include; ..\lib\STM32F7xx_HAL_Driver\Inc; ..\lib\STM32F7xx_HAL_Driver\Inc\Legacy; ..\lib\TinyUSB; ..\..\..\..\Source; ..\..\..\..\Source\ARMCM7_STM32F7; ..\..\..\..\Source\third_party\tinyusb\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openblt_stm32f746.srec
  ILINK.IlinkOutputFile: openblt_stm32f746.out
  ILINK.IlinkIcfFile: ..\stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Boot
    ../: blt_conf.h hooks.c led.c led.h main.c startup_stm32f746xx.s
  group Boot/lib
    ../lib/: stm32f7xx_hal_conf.h system_stm32f7xx.c
  group Boot/lib/CMSIS
    ../lib/CMSIS/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h tz_context.h
    ../lib/CMSIS/Device/ST/STM32F7xx/Include/: stm32f746xx.h stm32f7xx.h system_stm32f7xx.h
  group Boot/lib/HAL
    ../lib/STM32F7xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_can.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_ll_dma.c stm32f7xx_ll_exti.c stm32f7xx_ll_gpio.c stm32f7xx_ll_rcc.c stm32f7xx_ll_usart.c stm32f7xx_ll_usb.c stm32f7xx_ll_utils.c
    ../lib/STM32F7xx_HAL_Driver/Inc/: stm32f7xx_hal.h stm32f7xx_hal_can.h stm32f7xx_hal_cortex.h stm32f7xx_hal_def.h stm32f7xx_hal_dma.h stm32f7xx_hal_dma_ex.h stm32f7xx_hal_exti.h stm32f7xx_hal_flash.h stm32f7xx_hal_flash_ex.h stm32f7xx_hal_gpio.h stm32f7xx_hal_gpio_ex.h stm32f7xx_hal_i2c.h stm32f7xx_hal_i2c_ex.h stm32f7xx_hal_pcd.h stm32f7xx_hal_pcd_ex.h stm32f7xx_hal_pwr.h stm32f7xx_hal_pwr_ex.h stm32f7xx_hal_rcc.h stm32f7xx_hal_rcc_ex.h stm32f7xx_ll_bus.h stm32f7xx_ll_cortex.h stm32f7xx_ll_dma.h stm32f7xx_ll_exti.h stm32f7xx_ll_gpio.h stm32f7xx_ll_pwr.h stm32f7xx_ll_rcc.h stm32f7xx_ll_system.h stm32f7xx_ll_usart.h stm32f7xx_ll_usb.h stm32f7xx_ll_utils.h
  group Boot/lib/TinyUSB
    ../lib/TinyUSB/: tusb_config.h usb_descriptors.c
  group Source
    ../../../../Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h events.c events.h file.c file.h infotable.c infotable.h mb.c mb.h net.c net.h nvm.h plausibility.h rs232.h timer.h usb.h xcp.c xcp.h
  group Source/ARMCM7_STM32F7
    ../../../../Source/ARMCM7_STM32F7/: can.c cpu.c flash.c flash.h mbrtu.c nvm.c rs232.c timer.c types.h usb.c
  group Source/ARMCM7_STM32F7/IAR
    ../../../../Source/ARMCM7_STM32F7/IAR/: cpu_comp.c
  group Source/third_party/tinyusb
    ../../../../Source/third_party/tinyusb/src/device/: dcd.h usbd.c usbd.h usbd_control.c usbd_pvt.h
    ../../../../Source/third_party/tinyusb/src/portable/synopsys/dwc2/: dcd_dwc2.c dwc2_common.c dwc2_common.h dwc2_stm32.h dwc2_type.h
    ../../../../Source/third_party/tinyusb/src/osal/: osal.h osal_none.h
    ../../../../Source/third_party/tinyusb/src/: tusb.c tusb.h tusb_option.h
    ../../../../Source/third_party/tinyusb/src/common/: tusb_common.h tusb_compiler.h tusb_debug.h tusb_fifo.c tusb_fifo.h tusb_mcu.h tusb_private.h tusb_types.h tusb_verify.h
    ../../../../Source/third_party/tinyusb/src/portable/: usb_board.c
    ../../../../Source/third_party/tinyusb/src/class/vendor/: vendor_device.c vendor_device.h
