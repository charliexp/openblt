# IAR project stm32c092.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32C092RC ST STM32C092RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32C092xx
  ICCARM.CCIncludePath2: ..\lib; ..\lib\CMSIS\Device\ST\STM32C0xx\Include; ..\lib\CMSIS\Include; ..\lib\STM32C0xx_HAL_Driver\Inc; ..\lib\STM32C0xx_HAL_Driver\Inc\Legacy; ..\; ..\..\..\..\Source; ..\..\..\..\Source\ARMCM0_STM32C0
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openblt_stm32c092.srec
  ILINK.IlinkOutputFile: openblt_stm32c092.out
  ILINK.IlinkIcfFile: ..\stm32c092xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Boot
    ../: blt_conf.h flash_layout.c hooks.c led.c led.h main.c startup_stm32c092xx.s
  group Boot/lib
    ../lib/: stm32c0xx_hal_conf.h system_stm32c0xx.c
  group Boot/lib/CMSIS
    ../lib/CMSIS/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h
    ../lib/CMSIS/Device/ST/STM32C0xx/Include/: stm32c092xx.h stm32c0xx.h system_stm32c0xx.h
  group Boot/lib/HAL
    ../lib/STM32C0xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal.c stm32c0xx_hal_cortex.c stm32c0xx_hal_dma.c stm32c0xx_hal_dma_ex.c stm32c0xx_hal_exti.c stm32c0xx_hal_fdcan.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_ll_dma.c stm32c0xx_ll_exti.c stm32c0xx_ll_gpio.c stm32c0xx_ll_rcc.c stm32c0xx_ll_usart.c stm32c0xx_ll_utils.c
    ../lib/STM32C0xx_HAL_Driver/Inc/: stm32c0xx_hal.h stm32c0xx_hal_cortex.h stm32c0xx_hal_def.h stm32c0xx_hal_dma.h stm32c0xx_hal_dma_ex.h stm32c0xx_hal_exti.h stm32c0xx_hal_fdcan.h stm32c0xx_hal_flash.h stm32c0xx_hal_flash_ex.h stm32c0xx_hal_gpio.h stm32c0xx_hal_gpio_ex.h stm32c0xx_hal_pwr.h stm32c0xx_hal_pwr_ex.h stm32c0xx_hal_rcc.h stm32c0xx_hal_rcc_ex.h stm32c0xx_ll_bus.h stm32c0xx_ll_cortex.h stm32c0xx_ll_dma.h stm32c0xx_ll_dmamux.h stm32c0xx_ll_exti.h stm32c0xx_ll_gpio.h stm32c0xx_ll_pwr.h stm32c0xx_ll_rcc.h stm32c0xx_ll_system.h stm32c0xx_ll_usart.h stm32c0xx_ll_utils.h
  group Source
    ../../../../Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h events.c events.h file.c file.h infotable.c infotable.h mb.c mb.h net.c net.h nvm.h plausibility.h rs232.h timer.h usb.h xcp.c xcp.h
  group Source/ARMCM0_STM32C0
    ../../../../Source/ARMCM0_STM32C0/: can.c cpu.c flash.c flash.h mbrtu.c nvm.c rs232.c timer.c types.h
  group Source/ARMCM0_STM32C0/IAR
    ../../../../Source/ARMCM0_STM32C0/IAR/: cpu_comp.c
