# IAR project tm4c123g.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PGE TexasInstruments TM4C123GH6PGE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PGE; TM4C123GH6PGE; TARGET_IS_BLIZZARD_RA1; PRINTF_INCLUDE_CONFIG_H
  ICCARM.CCDiagSuppress: Pa050,Pa082,Pa039
  ICCARM.CCIncludePath2: ..\..\..\..\Source; ..\..\..\..\Source\third_party\fatfs\source; ..\..\..\..\Source\third_party\tinyusb\src; ..\..\..\..\Source\ARMCM4_TM4C; ..\..\..\..\Source\ARMCM4_TM4C\IAR; ..; ..\lib; ..\lib\inc; ..\lib\driverlib; ..\lib\fatfs; ..\lib\printf; ..\lib\cmsis\Include; ..\lib\cmsis\Device\TI\TM4C123; ..\lib\tinyusb
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..; ..\..\..\..\third_party
  OBJCOPY.OOCOutputFile: openblt_dk_tm4c123g.bin
  ILINK.IlinkOutputFile: openblt_dk_tm4c123g.out
  ILINK.IlinkIcfFile: ..\memory.x
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Boot
    ../: blt_conf.h cstart.s hooks.c led.c led.h main.c vectors.c
  group Boot/lib/cmsis
    ../lib/cmsis/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h tz_context.h
    ../lib/cmsis/Device/TI/TM4C123/: system_TM4C123.h TM4C123.h TM4C123GH6PGE.h
  group Boot/lib/driverlib
    ../lib/driverlib/: adc.c adc.h can.c can.h comp.c comp.h cpulib.c cpulib.h debug.h eeprom.c eeprom.h flashlib.c flashlib.h fpu.c fpu.h gpio.c gpio.h hibernate.c hibernate.h i2c.c i2c.h interrupt.c interrupt.h mpu.c mpu.h pin_map.h pwm.c pwm.h qei.c qei.h rom.h rom_map.h rtos_bindings.h ssi.c ssi.h sw_crc.c sw_crc.h sysctl.c sysctl.h sysexc.c sysexc.h systick.c systick.h timerlib.c timerlib.h uartlib.c uartlib.h udma.c udma.h usbdrv.c usbdrv.h watchdog.c watchdog.h
  group Boot/lib/fatfs
    ../lib/fatfs/: ffconf.h mmc.c
  group Boot/lib/printf
    ../lib/printf/: printf.c printf.h printf_config.h
  group Boot/lib/inc
    ../lib/inc/: asmdefs.h hw_adc.h hw_can.h hw_comp.h hw_eeprom.h hw_fan.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_ints.h hw_lpc.h hw_memmap.h hw_nvic.h hw_peci.h hw_pwm.h hw_qei.h hw_ssi.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h tm4c123gh6pge.h
  group Boot/lib/tinyusb
    ../lib/tinyusb/: tusb_config.h usb_descriptors.c
  group Source
    ../../../../Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h com.c com.h cop.c cop.h cpu.h events.c events.h file.c file.h infotable.c infotable.h mb.c mb.h nvm.h plausibility.h rs232.h timer.h usb.h xcp.c xcp.h
  group Source/ARMCM4_TM4C
    ../../../../Source/ARMCM4_TM4C/: cpu.c flash.c flash.h mbrtu.c nvm.c rs232.c timer.c types.h usb.c
  group Source/ARMCM4_TM4C/IAR
    ../../../../Source/ARMCM4_TM4C/IAR/: cpu_comp.c
  group Source/third_party/fatfs
    ../../../../Source/third_party/fatfs/source/: diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group Source/third_party/tinyusb
    ../../../../Source/third_party/tinyusb/src/device/: dcd.h usbd.c usbd.h usbd_control.c usbd_pvt.h
    ../../../../Source/third_party/tinyusb/src/portable/mentor/musb/: dcd_musb.c musb_ti.h musb_type.h
    ../../../../Source/third_party/tinyusb/src/osal/: osal.h osal_none.h
    ../../../../Source/third_party/tinyusb/src/: tusb.c tusb.h tusb_option.h
    ../../../../Source/third_party/tinyusb/src/common/: tusb_common.h tusb_compiler.h tusb_debug.h tusb_fifo.c tusb_fifo.h tusb_mcu.h tusb_private.h tusb_types.h tusb_verify.h
    ../../../../Source/third_party/tinyusb/src/portable/: usb_board.c
    ../../../../Source/third_party/tinyusb/src/class/vendor/: vendor_device.c vendor_device.h
