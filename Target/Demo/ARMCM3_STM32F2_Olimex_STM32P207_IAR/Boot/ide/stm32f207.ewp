# IAR project stm32f207.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZE ST STM32F207ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; USE_FULL_LL_DRIVER; STM32F207xx; PRINTF_INCLUDE_CONFIG_H
  ICCARM.CCIncludePath2: ..; ..\lib; ..\lib\CMSIS\Device\ST\STM32F2xx\Include; ..\lib\CMSIS\Include; ..\lib\fatfs; ..\lib\printf; ..\lib\STM32F2xx_HAL_Driver\Inc; ..\lib\STM32F2xx_HAL_Driver\Inc\Legacy; ..\..\..\..\Source; ..\..\..\..\Source\ARMCM3_STM32F2; ..\..\..\..\Source\third_party\fatfs\source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openblt_stm32f207.srec
  ILINK.IlinkOutputFile: openblt_stm32f207.out
  ILINK.IlinkIcfFile: ..\stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Boot
    ../: blt_conf.h hooks.c led.c led.h main.c startup_stm32f2xx.s
  group Boot/lib
    ../lib/: stm32f2xx_hal_conf.h system_stm32f2xx.c
  group Boot/lib/CMSIS
    ../lib/CMSIS/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm3.h tz_context.h
    ../lib/CMSIS/Device/ST/STM32F2xx/Include/: stm32f207xx.h stm32f2xx.h system_stm32f2xx.h
  group Boot/lib/fatfs
    ../lib/fatfs/: ffconf.h mmc.c
  group Boot/lib/HAL
    ../lib/STM32F2xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_can.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_exti.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_ll_dma.c stm32f2xx_ll_exti.c stm32f2xx_ll_gpio.c stm32f2xx_ll_rcc.c stm32f2xx_ll_spi.c stm32f2xx_ll_usart.c stm32f2xx_ll_utils.c
    ../lib/STM32F2xx_HAL_Driver/Inc/: stm32f2xx_hal.h stm32f2xx_hal_can.h stm32f2xx_hal_cortex.h stm32f2xx_hal_def.h stm32f2xx_hal_dma.h stm32f2xx_hal_dma_ex.h stm32f2xx_hal_exti.h stm32f2xx_hal_flash.h stm32f2xx_hal_flash_ex.h stm32f2xx_hal_gpio.h stm32f2xx_hal_gpio_ex.h stm32f2xx_hal_pwr.h stm32f2xx_hal_pwr_ex.h stm32f2xx_hal_rcc.h stm32f2xx_hal_rcc_ex.h stm32f2xx_ll_bus.h stm32f2xx_ll_cortex.h stm32f2xx_ll_dma.h stm32f2xx_ll_exti.h stm32f2xx_ll_gpio.h stm32f2xx_ll_pwr.h stm32f2xx_ll_rcc.h stm32f2xx_ll_spi.h stm32f2xx_ll_system.h stm32f2xx_ll_usart.h stm32f2xx_ll_utils.h
  group Boot/lib/printf
    ../lib/printf/: printf.c printf.h printf_config.h
  group Source
    ../../../../Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h events.c events.h file.c file.h infotable.c infotable.h mb.c mb.h net.c net.h nvm.h plausibility.h rs232.h timer.h usb.h xcp.c xcp.h
  group Source/ARMCM3_STM32F2
    ../../../../Source/ARMCM3_STM32F2/: can.c cpu.c flash.c flash.h mbrtu.c nvm.c rs232.c timer.c types.h
  group Source/ARMCM3_STM32F2/IAR
    ../../../../Source/ARMCM3_STM32F2/IAR/: cpu_comp.c
  group Source/third_party/fatfs
    ../../../../Source/third_party/fatfs/source/: diskio.h ff.c ff.h ffsystem.c ffunicode.c
