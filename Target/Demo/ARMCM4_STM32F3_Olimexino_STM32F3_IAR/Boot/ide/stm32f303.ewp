# IAR project stm32f303.ewp, settings and files
configuration Boot (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303RC ST STM32F303RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32F303xC; PRINTF_INCLUDE_CONFIG_H
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..; ..\lib; ..\lib\CMSIS\Device\ST\STM32F3xx\Include; ..\lib\CMSIS\Include; ..\lib\STM32F3xx_HAL_Driver\Inc; ..\lib\STM32F3xx_HAL_Driver\Inc\Legacy; ..\lib\TinyUSB; ..\lib\printf; ..\lib\fatfs; ..\..\..\..\Source; ..\..\..\..\Source\ARMCM4_STM32F3; ..\..\..\..\Source\third_party\fatfs\source; ..\..\..\..\Source\third_party\tinyusb\src
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openblt_olimexino_stm32f3.srec
  ILINK.IlinkOutputFile: openblt_olimexino_stm32f3.out
  ILINK.IlinkIcfFile: ..\stm32f303xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Boot
    ../: blt_conf.h flash_layout.c hooks.c led.c led.h main.c startup_stm32f303xc.s
  group Boot/lib
    ../lib/: stm32f3xx_hal_conf.h system_stm32f3xx.c
  group Boot/lib/CMSIS
    ../lib/CMSIS/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm4.h tz_context.h
    ../lib/CMSIS/Device/ST/STM32F3xx/Include/: stm32f303xc.h stm32f3xx.h system_stm32f3xx.h
  group Boot/lib/fatfs
    ../lib/FatFS/: ffconf.h mmc.c
  group Boot/lib/HAL_Driver
    ../lib/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_can.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_exti.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_ll_dma.c stm32f3xx_ll_exti.c stm32f3xx_ll_gpio.c stm32f3xx_ll_rcc.c stm32f3xx_ll_spi.c stm32f3xx_ll_usart.c stm32f3xx_ll_usb.c stm32f3xx_ll_utils.c
    ../lib/STM32F3xx_HAL_Driver/Inc/: stm32f3xx_hal.h stm32f3xx_hal_can.h stm32f3xx_hal_cortex.h stm32f3xx_hal_def.h stm32f3xx_hal_dma.h stm32f3xx_hal_dma_ex.h stm32f3xx_hal_exti.h stm32f3xx_hal_flash.h stm32f3xx_hal_flash_ex.h stm32f3xx_hal_gpio.h stm32f3xx_hal_gpio_ex.h stm32f3xx_hal_i2c.h stm32f3xx_hal_i2c_ex.h stm32f3xx_hal_pcd.h stm32f3xx_hal_pcd_ex.h stm32f3xx_hal_pwr.h stm32f3xx_hal_pwr_ex.h stm32f3xx_hal_rcc.h stm32f3xx_hal_rcc_ex.h stm32f3xx_ll_bus.h stm32f3xx_ll_cortex.h stm32f3xx_ll_dma.h stm32f3xx_ll_exti.h stm32f3xx_ll_gpio.h stm32f3xx_ll_pwr.h stm32f3xx_ll_rcc.h stm32f3xx_ll_spi.h stm32f3xx_ll_system.h stm32f3xx_ll_usart.h stm32f3xx_ll_usb.h stm32f3xx_ll_utils.h
  group Boot/lib/printf
    ../lib/printf/: printf.c printf.h printf_config.h
  group Boot/lib/TinyUSB
    ../lib/TinyUSB/: tusb_config.h usb_descriptors.c
  group Source
    ../../../../Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h events.c events.h file.c file.h infotable.c infotable.h mb.c mb.h net.c net.h nvm.h plausibility.h rs232.h timer.h usb.h xcp.c xcp.h
  group Source/ARMCM4_STM32F3
    ../../../../Source/ARMCM4_STM32F3/: can.c cpu.c flash.c flash.h mbrtu.c nvm.c rs232.c timer.c types.h usb.c
  group Source/ARMCM4_STM32F3/IAR
    ../../../../Source/ARMCM4_STM32F3/IAR/: cpu_comp.c
  group Source/third_party/fatfs
    ../../../../Source/third_party/fatfs/source/: diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group Source/third_party/tinyusb
    ../../../../Source/third_party/tinyusb/src/device/: dcd.h usbd.c usbd.h usbd_control.c usbd_pvt.h
    ../../../../Source/third_party/tinyusb/src/portable/st/stm32_fsdev/: dcd_stm32_fsdev.c fsdev_stm32.h fsdev_type.h
    ../../../../Source/third_party/tinyusb/src/osal/: osal.h osal_none.h
    ../../../../Source/third_party/tinyusb/src/: tusb.c tusb.h tusb_option.h
    ../../../../Source/third_party/tinyusb/src/common/: tusb_common.h tusb_compiler.h tusb_debug.h tusb_fifo.c tusb_fifo.h tusb_mcu.h tusb_private.h tusb_types.h tusb_verify.h
    ../../../../Source/third_party/tinyusb/src/portable/: usb_board.c
    ../../../../Source/third_party/tinyusb/src/class/vendor/: vendor_device.c vendor_device.h
