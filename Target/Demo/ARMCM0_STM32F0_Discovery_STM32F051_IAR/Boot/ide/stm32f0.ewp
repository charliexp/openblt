# IAR project stm32f0.ewp, settings and files
configuration stm32f0 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051R8 ST STM32F051R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F051x8; USE_FULL_LL_DRIVER; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\lib; ..\lib\CMSIS\Device\ST\STM32F0xx\Include; ..\lib\CMSIS\Include; ..\lib\STM32F0xx_HAL_Driver\Inc; ..\lib\STM32F0xx_HAL_Driver\Inc\Legacy; ..\..\..\..\Source; ..\..\..\..\Source\ARMCM0_STM32F0; ..\
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openblt_stm32f051.srec
  ILINK.IlinkOutputFile: openblt_stm32f051.out
  ILINK.IlinkIcfFile: ..\stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group lib
    ../lib/: stm32f0xx_hal_conf.h system_stm32f0xx.c
  group lib/CMSIS
    ../lib/CMSIS/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
    ../lib/CMSIS/Device/ST/STM32F0xx/Include/: stm32f051x8.h stm32f0xx.h system_stm32f0xx.h
  group lib/HAL
    ../lib/STM32F0xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_exti.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_ll_dma.c stm32f0xx_ll_exti.c stm32f0xx_ll_gpio.c stm32f0xx_ll_rcc.c stm32f0xx_ll_usart.c stm32f0xx_ll_utils.c
    ../lib/STM32F0xx_HAL_Driver/Inc/: stm32f0xx_hal.h stm32f0xx_hal_cortex.h stm32f0xx_hal_def.h stm32f0xx_hal_dma.h stm32f0xx_hal_dma_ex.h stm32f0xx_hal_exti.h stm32f0xx_hal_flash.h stm32f0xx_hal_flash_ex.h stm32f0xx_hal_gpio.h stm32f0xx_hal_gpio_ex.h stm32f0xx_hal_i2c.h stm32f0xx_hal_i2c_ex.h stm32f0xx_hal_pwr.h stm32f0xx_hal_pwr_ex.h stm32f0xx_hal_rcc.h stm32f0xx_hal_rcc_ex.h stm32f0xx_ll_bus.h stm32f0xx_ll_cortex.h stm32f0xx_ll_crs.h stm32f0xx_ll_dma.h stm32f0xx_ll_exti.h stm32f0xx_ll_gpio.h stm32f0xx_ll_pwr.h stm32f0xx_ll_rcc.h stm32f0xx_ll_system.h stm32f0xx_ll_usart.h stm32f0xx_ll_utils.h
  group src
    ../: blt_conf.h flash_layout.c hooks.c led.c led.h main.c startup_stm32f051x8.s
  group src/core
    ../../../../Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h events.c events.h file.c file.h infotable.c infotable.h mb.c mb.h net.c net.h nvm.h plausibility.h rs232.h timer.h usb.h xcp.c xcp.h
    ../../../../Source/ARMCM0_STM32F0/: cpu.c flash.c flash.h mbrtu.c nvm.c rs232.c timer.c types.h
    ../../../../Source/ARMCM0_STM32F0/IAR/: cpu_comp.c
